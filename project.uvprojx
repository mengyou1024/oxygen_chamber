# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F207VC GigaDevice
  pack: GigaDevice.GD32F20x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x020000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, RT_USING_LIBC, GD32F20X_CL, RT_USING_ARM_LIBC, __RTTHREAD__
  c include: applications;.;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m3;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;packages\dhtxx-latest\inc;board;libraries\gd32_drivers;rt-thread\components\finsh;.;rt-thread\include;libraries\GD32F20x_Firmware_Library\CMSIS\GD\GD32F20x\Include;libraries\GD32F20x_Firmware_Library\CMSIS;libraries\GD32F20x_Firmware_Library\GD32F20x_standard_peripheral\Include;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Applications
    applications/: main.c
    applications/sensors/: lcd_3_5_inch.c sco3_o2.c nai_conc.c lcd_7_inch.c o2_conc.c gas_pressure.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group dhtxx
    packages/dhtxx-latest/src/: dhtxx.c
  group Drivers
    board/: board.c
    libraries/GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
    libraries/gd32_drivers/: drv_adc.c drv_gpio.c drv_usart.c drv_wdt.c
  group Finsh
    rt-thread/components/finsh/: msh.c msh_parse.c shell.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    libraries/GD32F20x_Firmware_Library/GD32F20x_standard_peripheral/Source/: gd32f20x_rcu.c gd32f20x_misc.c gd32f20x_exti.c gd32f20x_wwdgt.c gd32f20x_usart.c gd32f20x_adc.c gd32f20x_gpio.c gd32f20x_fwdgt.c
    libraries/GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
software components: CMSIS:CORE 5.1.2
